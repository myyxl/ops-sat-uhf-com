options:
  parameters:
    author: Fischer Benjamin, Mladenov Tom, Marlon Starkloff
    description: UHF RX application
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: OPS-SAT UHF RX
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: true_freq - signal_freq
  states: {}
- name: freq_tuned
  id: variable
  parameters:
    value: offset_freq - doppler_freq
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian (1.5, 2* (samp_rate_down / baud_rate) , 0.5, 12)
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: '-40e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate_down
  id: variable
  parameters:
    value: 57.6e3
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 437.2e6
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-130'
  states: {}
- name: true_freq
  id: variable
  parameters:
    value: signal_freq
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '25000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 2 * (samp_rate_down / baud_rate) /(math.pi)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/marlon/Desktop/gr-opssat/recordings/osat_437.16M_200k_beacon_mode6.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: (samp_rate_down / baud_rate)*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: gaussian_taps
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_tuned'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: true_freq
  states: {}
- name: gpredict_doppler_1_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Determined by Gpredict
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: GMSK9k6
  states: {}
- name: note_1
  id: note
  parameters:
    note: Satellite frequency
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Offset sampling
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Squelch
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    name: '"OPS-SAT UHF BEACON"'
    showports: 'True'
    type: complex
    update_time: '0.03'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(samp_rate_down)
    taps: ''
    type: ccc
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: sample
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sample
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_simple_squelch_cc_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', satellites_ax25_deframer_0, '0']
- [fir_filter_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [gpredict_doppler_1_0, freq, blocks_message_debug_0, print]
- [gpredict_doppler_1_0, freq, gpredict_MsgPairToVar_0, inpair]
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0_0_1, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_1, print]
- [satellites_ax25_deframer_0, out, zeromq_pub_msg_sink_0, in]
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
